# Keil uVision project SWM2X1_IEC60335.uvprojx, settings and files
target SWM2X1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM211x8 Synwit
  pack: Synwit.SWM32_DFP.2.0.5
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: SWM2X1_IEC60335 +hex
  AfterMake: "do_crc32_keil.bat"
  AfterMake: fromelf --text -a -c -o "$L@L.asm" "#L"
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c define: CHIP_SWM211, STL_VERBOSE
  c include: .\CSL\CMSIS\CoreSupport;.\CSL\CMSIS\DeviceSupport;.\CSL\SWM2X1_StdPeriph_Driver;.\SelfTestLib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\APP\SWM2X1_ClassB.sct
  group APP
    ./app/: main.c
  group CSL\StdPD
    ./CSL/SWM2X1_StdPeriph_Driver/: SWM2X1_adc.c SWM2X1_can.c SWM2X1_cordic.c SWM2X1_div.c SWM2X1_dma.c SWM2X1_exti.c SWM2X1_gpio.c SWM2X1_i2c.c SWM2X1_iofilt.c SWM2X1_mpu.c SWM2X1_port.c SWM2X1_pwm.c SWM2X1_qei.c SWM2X1_rtc.c SWM2X1_sleep.c SWM2X1_spi.c SWM2X1_timr.c SWM2X1_uart.c SWM2X1_wdt.c SWM211_flash.c
  group CSL\CMSIS
    ./CSL/CMSIS/DeviceSupport/: system_SWM211.c
    ./CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM211.s
  group SelfTestLib
    ./SelfTestLib/: SWM2X1_STLstartup.c SWM2X1_STLmain.c SWM2X1_STLclockrun.c SWM2X1_STLclockstart.c SWM2X1_STLmisc.c SWM2X1_STLcrc32.c SWM2X1_STLcrc32Run.c SWM2X1_STLfullRamMc.c SWM2X1_STLtranspRamMc.c SWM2X1_STLtranspRamMx.c SWM2X1_STLcpurunKEIL.s SWM2X1_STLcpustartKEIL.s
software components: CMSIS:CORE 5.6.0
