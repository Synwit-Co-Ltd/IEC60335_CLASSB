# Keil uVision project SWM241_IEC60335.uvprojx, settings and files
target SWM241 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM241xB Synwit
  pack: Synwit.SWM32_New.0.0.9
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: SWM241_IEC60335 +hex
  AfterMake: "do_crc32_keil.bat"
  AfterMake: fromelf --text -a -c -o "$L@L.asm" "#L"
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c define: STL_VERBOSE
  c include: .\CSL\CMSIS\CoreSupport;.\CSL\CMSIS\DeviceSupport;.\CSL\SWM241_StdPeriph_Driver;.\SelfTestLib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\APP\SWM241_ClassB.sct
  group APP
    ./app/: main.c
  group CSL\StdPD
    ./CSL/SWM241_StdPeriph_Driver/: SWM241_adc.c SWM241_exti.c SWM241_gpio.c SWM241_i2c.c SWM241_pwm.c SWM241_timr.c SWM241_uart.c SWM241_wdt.c SWM241_flash.c SWM241_port.c SWM241_spi.c SWM241_dma.c SWM241_div.c SWM241_rtc.c SWM241_sleep.c SWM241_safety.c SWM241_crc.c
  group CSL\CMSIS
    ./CSL/CMSIS/DeviceSupport/: system_SWM241.c
    ./CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM241.s
  group SelfTestLib
    ./SelfTestLib/: SWM241_STLclockrun.c SWM241_STLclockstart.c SWM241_STLcrc32.c SWM241_STLcrc32Run.c SWM241_STLfullRamMc.c SWM241_STLmain.c SWM241_STLmisc.c SWM241_STLstartup.c SWM241_STLtranspRamMc.c SWM241_STLtranspRamMx.c SWM241_STLcpurunKEIL.s SWM241_STLcpustartKEIL.s
software components: CMSIS:CORE 5.4.0
