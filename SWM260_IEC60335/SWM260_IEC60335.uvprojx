# Keil uVision project SWM260_IEC60335.uvprojx, settings and files
target SWM260 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM260xB Synwit
  pack: Synwit.SWM32_DFP.2.0.5
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: SWM260_IEC60335 +hex
  AfterMake: "do_crc32_keil.bat"
  AfterMake: fromelf --text -a -c -o "$L@L.asm" "#L"
  c flags: Optim=2 v6Lang=3 v6LangP=3 wLevel=2
  c define: STL_VERBOSE
  c include: .\CSL\SWM260_StdPeriph_Driver;.\CSL\CMSIS\CoreSupport;.\CSL\CMSIS\DeviceSupport;.\SelfTestLib
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1e000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\APP\SWM260_ClassB.sct
  group APP
    ./APP/: main.c
  group CSL/Std
    ./CSL/SWM260_StdPeriph_Driver/: SWM260_adc.c SWM260_dma.c SWM260_exti.c SWM260_flash.c SWM260_gpio.c SWM260_i2c.c SWM260_port.c SWM260_pwm.c SWM260_rtc.c SWM260_sleep.c SWM260_spi.c SWM260_timr.c SWM260_uart.c SWM260_wdt.c
  group CSL/CMSIS
    ./CSL/CMSIS/DeviceSupport/: system_SWM260.c
    ./CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM260.s
  group SelfTestLib
    ./SelfTestLib/: SWM260_STLclockrun.c SWM260_STLclockstart.c SWM260_STLcrc32.c SWM260_STLcrc32Run.c SWM260_STLfullRamMc.c SWM260_STLmain.c SWM260_STLmisc.c SWM260_STLstartup.c SWM260_STLtranspRamMc.c SWM260_STLtranspRamMx.c SWM260_STLcpurunKEIL.s SWM260_STLcpustartKEIL.s
