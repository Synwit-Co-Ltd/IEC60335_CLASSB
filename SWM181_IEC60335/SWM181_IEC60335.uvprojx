# Keil uVision project SWM181_IEC60335.uvprojx, settings and files
target SWM181 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM181xC Synwit
  pack: Synwit.SWM32_DFP.2.0.5
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x3E000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: SWM181_IEC60335 +hex
  AfterMake: "do_crc32_keil.bat"
  AfterMake: fromelf --text -a -c -o "$L@L.asm" "#L"
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c include: .\CSL\CMSIS\CoreSupport;.\CSL\CMSIS\DeviceSupport;.\SelfTestLib;.\CSL\SWM181_StdPeriph_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\APP\SWM181_ClassB.sct
  group APP
    ./app/: main.c
  group CSL\StdPD
    ./CSL/SWM181_StdPeriph_Driver/: SWM181_adc.c SWM181_cache.c SWM181_can.c SWM181_cmp.c SWM181_cordic.c SWM181_div.c SWM181_dma.c SWM181_exti.c SWM181_flash.c SWM181_gpio.c SWM181_i2c.c SWM181_irqmux.c SWM181_port.c SWM181_pwm.c SWM181_sdadc.c SWM181_slcd.c SWM181_sleep.c SWM181_spi.c SWM181_timr.c SWM181_uart.c SWM181_wdt.c
  group CSL\CMSIS
    ./CSL/CMSIS/DeviceSupport/: system_SWM181.c
    ./CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM181.s
  group SelfTestLib
    ./SelfTestLib/: SWM181_STLstartup.c SWM181_STLmain.c SWM181_STLclockrun.c SWM181_STLclockstart.c SWM181_STLmisc.c SWM181_STLcrc32.c SWM181_STLcrc32Run.c SWM181_STLfullRamMc.c SWM181_STLtranspRamMc.c SWM181_STLtranspRamMx.c SWM181_STLcpurunKEIL.s SWM181_STLcpustartKEIL.s
software components: CMSIS:CORE 5.4.0
