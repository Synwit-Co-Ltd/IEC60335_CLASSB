# Keil uVision project SWM341_IEC60335.uvprojx, settings and files
target SWM341 (6150000::V6.15::ARMCLANG)
  device: SWM341xE Synwit
  pack: Synwit.SWM32_DFP.2.0.5
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: SWM341_IEC60335 +hex
  AfterMake: "do_crc32_keil.bat"
  AfterMake: fromelf --text -a -c -o "$L@L.asm" "#L"
  c flags: Optim=1 v6Lang=3 v6LangP=1 wLevel=3
  c include: .\APP;.\CLASSB_LIB;..\SWM341_StdPeriph_Driver;.\CSL\CMSIS\CoreSupport;.\CSL\CMSIS\DeviceSupport;.\CSL\SWM341_StdPeriph_Driver;..\SWM341_StdPeriph_Driver;.\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\APP\SWM341_ClassB.sct
  group APP
    ./app/: main.c
    ./APP/: uart.c SWM341_SelfTest_cpurunKEIL.s SWM341_SelfTest_RamMcMxKEIL.s SWM341_STLcpustartKEIL.s
    ./: CRC32_fast_static_lut.c
  group CSL\StdPD
    ./CSL/SWM341_StdPeriph_Driver/: SWM341_port.c SWM341_gpio.c SWM341_exti.c SWM341_timr.c SWM341_uart.c SWM341_adc.c SWM341_dma.c SWM341_i2c.c SWM341_pwm.c SWM341_can.c SWM341_spi.c SWM341_lcd.c SWM341_flash.c SWM341_crc.c SWM341_rtc.c SWM341_wdt.c SWM341_cordic.c SWM341_sleep.c SWM341_usbd.c SWM341_div.c SWM341_sdio.c SWM341_sdram.c SWM341_dac.c SWM341_jpeg.c SWM341_sfc.c
  group CSL\CMSIS
    ./CSL/CMSIS/DeviceSupport/: system_SWM341.c
    ./CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM341.s
  group CLASSB_LIB
    ./CLASSB_LIB/: SWM341xx_SelfTest_clockrun.c SWM341xx_SelfTest_clockstart.c SWM341xx_SelfTest_crc32Run.c SWM341xx_SelfTest_main.c SWM341xx_SelfTest_startup.c SWM341xx_SelfTest_transpRam.c
