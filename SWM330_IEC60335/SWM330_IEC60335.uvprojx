# Keil uVision project SWM330_IEC60335.uvprojx, settings and files
target SWM330 (6160000::V6.16::ARMCLANG)
  device: SWM330xG Synwit
  pack: Synwit.SWM32_New.0.2.9
  cpu: CPUTYPE("Cortex-M33") DSP CLOCK(12000000) ESEL ELITTLE
  output: SWM330_IEC60335 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf --text -a -c -o "$L@L.asm" "#L"
  c flags: Optim=1 v6Lang=3 v6LangP=1 wLevel=3
  c include: .\CSL\CMSIS\CoreSupport;.\CSL\CMSIS\DeviceSupport;.\CSL\SWM330_StdPeriph_Driver;.\SelfTestLib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: .\APP\SWM330_ClassB.sct
  group APP
    ./app/: main.c
  group CSL\StdPD
    ./CSL/SWM330_StdPeriph_Driver/: SWM330_port.c SWM330_gpio.c SWM330_exti.c SWM330_timr.c SWM330_uart.c SWM330_adc.c SWM330_dma.c SWM330_i2c.c SWM330_pwm.c SWM330_can.c SWM330_spi.c SWM330_lcd.c SWM330_flash.c SWM330_crc.c SWM330_rtc.c SWM330_wdt.c SWM330_sleep.c SWM330_sdio.c SWM330_dac.c SWM330_jpeg.c SWM330_dma2d.c SWM330_sra.c SWM330_qspi.c SWM330_i2s.c SWM330_psram.c SWM330_dvp.c SWM330_rdma.c
  group CSL\CMSIS
    ./CSL/CMSIS/DeviceSupport/: system_SWM330.c
    ./CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM330.s
  group SelfTestLib
    ./SelfTestLib/: STL_clockrun.c STL_clockstart.c STL_crc32.c STL_crc32Run.c STL_fullRamMc.c STL_main.c STL_misc.c STL_startup.c STL_transpRamMc.c STL_transRamMx.c STL_cpurunKeil.s STL_cpustartKEIL.s
